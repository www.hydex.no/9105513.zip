# Autodesk Inventor part: DVLF50_35_body
## iProperties
Created: 2010-03
Part Number: DVLF50_35_body
Document SubType Name: Modeling
Designer: TB
Mass: 507.874 g
Surface Area: 1102.64 cm^2
Volume: 507.874 cm^3
Density: 1 g/cm^3
Author: TB
## Feature names
1. Kropp [Revolution]
2. Chamfer
3. Extrusion2
4. Hole1
5. Revolution2
6. Hole2
7. Fillet1
8. Extrusion3
9. Hole3
